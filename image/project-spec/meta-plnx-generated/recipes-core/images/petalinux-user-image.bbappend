IMAGE_INSTALL_append = "\
		git \
		vim \
		cmake \
		packagegroup-xfce-base \
		kernel-modules \
		opencv \
		lxdm \
		unzip \
		tar \
		gst-player \
		"
