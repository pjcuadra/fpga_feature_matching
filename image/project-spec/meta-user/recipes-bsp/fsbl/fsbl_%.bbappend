do_configure() {
}

do_compile() {
}
